# IAR project SmartCar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\projects\SmartCar; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\chshell; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\CarUI; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\user; ..\..\build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SmartCar.hex
  ILINK.IlinkOutputFile: SmartCar.out
  ILINK.IlinkIcfFile: E:\Study\Freescale\My\PointRace\project\Version2\build\config files\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\projects\SmartCar; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\user; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\chshell; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\CarUI; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\build
  ILINK.IlinkIcfFile: ..\..\build\config files\fire_ROM_K60N512.icf
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/LIB/CMSIS/: arm_math.h
    ../../src/common/: common.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/projects/SmartCar/: include.h isr.h
    ../../src/platforms/: k60_fire.h
    ../../src/drivers/uart/: uart.h
  group user
    ../../src/user/: Device.h FuzzyCtrl.c FuzzyCtrl.h GlobalVars.c GlobalVars.h InitAll.c InitAll.h Misc.c Misc.h Sensor.c Sensor.h
    ../../src/app/: isr.c main.c
    ../../src/drivers/OLED/: OLED.c OLED.h
